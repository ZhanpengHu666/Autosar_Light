# IAR project IarStartApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K148 NXP S32K148
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __ICCARM__; CPU_S32K148; DISABLE_MCAL_INTERMODULE_ASR_CHECK; BRS_DERIVATIVE_S32K148; BASIC_RUNTIME_SYSTEM_TYPE_MSR4; DISABLE_WDOG
  ICCARM.CCIncludePath2: Src\Devices; Src\Isr; Src\Mcal\Adc_TS_T40D2M10I1R0\include; Src\Mcal\Base_TS_T40D2M10I1R0\include; Src\Mcal\Dio_TS_T40D2M10I1R0\include; Src\Mcal\Eep_TS_T40D2M10I1R0\include; Src\Mcal\Fls_TS_T40D2M10I1R0\include; Src\Mcal\Gpt_TS_T40D2M10I1R0\include; Src\Mcal\Icu_TS_T40D2M10I1R0\include; Src\Mcal\Mcl_TS_T40D2M10I1R0\include; Src\Mcal\Mcu_TS_T40D2M10I1R0\include; Src\Mcal\Port_TS_T40D2M10I1R0\include; Src\Mcal\Port_TS_T40D2M10I1R0\include; Src\Mcal\Spi_TS_T40D2M10I1R0\include; Src\Mcal\Wdg_TS_T40D2M10I1R0\include; Src\Mcal\GenCode\Include; Src\Bsw\BswM; Src\Bsw\Common; Src\Bsw\Can; Src\Bsw\CanIf; Src\Bsw\CanSM; Src\Bsw\CanTp; Src\Bsw\Com; Src\Bsw\ComM; Src\Bsw\Crc; Src\Bsw\Dcm; Src\Bsw\Dem; Src\Bsw\Det; Src\Bsw\Ea; Src\Bsw\EcuM; Src\Bsw\MemIf; Src\Bsw\Nm; Src\Bsw\NmOsek; Src\Bsw\NvM; Src\Bsw\Os; Src\Bsw\PduR; Src\Bsw\RamTst; Src\Bsw\VStdLib; Src\Bsw\GenCode; Src\Bsw\WdgIf; Src\Bsw\WdgM; Src\App\RamTst; Src\App\Os; Src\App\Component; Src\Mcal\Pwm_TS_T40D2M10I1R0\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__; CPU_S32K148; DISABLE_MCAL_INTERMODULE_ASR_CHECK; BRS_DERIVATIVE_S32K148; OS_LINK_CODE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: IarStartApp.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Vector\CBD1800257_D01_S32K1xx_CANNM\Applications\IarStartApp\Src\Devices\S32K148Asr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group App/Os
    Src/App/Os/: BswInit.c BswM_Callout_Stubs.c Cdd_Com.c Cdd_Tp.c Dcm_Callout_Stubs.c EcuM_Callout_Stubs.c Os_Callout_Stubs.c StartApplication.c StartApplicationMemoryAccessState.c StartApplicationTrusted.c
  group App/RamTst
    Src/App/RamTst/: Appl_RamTst.c
  group Bsw/BswM
    Src/Bsw/BswM/: BswM.c
  group Bsw/Can
    Src/Bsw/Can/: Can.c Can_Irq.c
  group Bsw/CanIf
    Src/Bsw/CanIf/: CanIf.c
  group Bsw/CanSM
    Src/Bsw/CanSM/: CanSM.c
  group Bsw/CanTp
    Src/Bsw/CanTp/: CanTp.c
  group Bsw/Com
    Src/Bsw/Com/: Com.c
  group Bsw/ComM
    Src/Bsw/ComM/: ComM.c
  group Bsw/Common
    Src/Bsw/Common/: Compiler.h Compiler_Cfg.h
  group Bsw/Crc
    Src/Bsw/Crc/: Crc.c
  group Bsw/Dcm
    Src/Bsw/Dcm/: Dcm.c Dcm_Ext.c
  group Bsw/Dem
    Src/Bsw/Dem/: Dem.c
  group Bsw/Det
    Src/Bsw/Det/: Det.c
  group Bsw/Ea
    Src/Bsw/Ea/: Ea.c Ea_BlockHandler.c Ea_DatasetHandler.c Ea_EepCoordinator.c Ea_InstanceHandler.c Ea_Layer1_Erase.c Ea_Layer1_Invalidate.c Ea_Layer1_Read.c Ea_Layer1_Write.c Ea_Layer2_InstanceFinder.c Ea_Layer2_InvalidateInstance.c Ea_Layer2_WriteInstance.c Ea_Layer3_ReadManagementBytes.c Ea_PartitionHandler.c Ea_TaskManager.c
  group Bsw/EcuM
    Src/Bsw/EcuM/: EcuM.c
  group Bsw/GenCode
    Src/Bsw/GenCode/: BswM_Lcfg.c BswM_PBcfg.c Can_Lcfg.c Can_PBcfg.c CanIf_Lcfg.c CanIf_PBcfg.c CanSM_Lcfg.c CanTp_Lcfg.c CanTp_PBcfg.c Com_Lcfg.c Com_PBcfg.c ComM_Lcfg.c ComM_PBcfg.c Dcm_Lcfg.c Dcm_PBcfg.c Dem_Lcfg.c Dem_PBcfg.c Det_Cfg.c Ea_Cfg.c EcuM_Cfg.c EcuM_Init_Cfg.c EcuM_Init_PBcfg.c EcuM_PBcfg.c MemIf_Cfg.c Nm_Cfg.c Nm_Lcfg.c NmOsek_Cfg.c NmOsek_PBcfg.c NvM_Cfg.c Os_AccessCheck_Lcfg.c Os_Alarm_Lcfg.c Os_Application_Lcfg.c Os_Barrier_Lcfg.c Os_Core_Lcfg.c Os_Counter_Lcfg.c Os_Error_Lcfg.c Os_Hal_Context_Lcfg.c Os_Hal_Core_Lcfg.c Os_Hal_Entry_Lcfg.c Os_Hal_EntryAsm_Lcfg.asm Os_Hal_Interrupt_Lcfg.c Os_Hal_Kernel_Lcfg.c Os_Hal_MemoryProtection_Lcfg.c Os_Hal_Timer_Lcfg.c Os_Hook_Lcfg.c Os_Ioc_Lcfg.c Os_Isr_Lcfg.c Os_MemoryProtection_Lcfg.c Os_Peripheral_Lcfg.c Os_Resource_Lcfg.c Os_Scheduler_Lcfg.c Os_ScheduleTable_Lcfg.c Os_ServiceFunction_Lcfg.c Os_Spinlock_Lcfg.c Os_Stack_Lcfg.c Os_Task_Lcfg.c Os_TimingProtection_Lcfg.c Os_Trace_Lcfg.c Os_XSignal_Lcfg.c PduR_Lcfg.c PduR_PBcfg.c RamTst_Lcfg.c Rte.c WdgIf_Lcfg.c WdgM_Cfg.c
  group Bsw/MemIf
    Src/Bsw/MemIf/: MemIf.c
  group Bsw/Nm
    Src/Bsw/Nm/: Nm.c
  group Bsw/NmOsek
    Src/Bsw/NmOsek/: NmOsek.c
  group Bsw/NvM
    Src/Bsw/NvM/: NvM.c NvM_Act.c NvM_Crc.c NvM_JobProc.c NvM_Qry.c NvM_Queue.c
  group Bsw/Os
    Src/Bsw/Os/: Os_AccessCheck.c Os_Alarm.c Os_Application.c Os_Barrier.c Os_Bit.c Os_BitArray.c Os_Core.c Os_Counter.c Os_Deque.c Os_Error.c Os_Event.c Os_Fifo.c Os_Fifo08.c Os_Fifo16.c Os_Fifo32.c Os_FifoRef.c Os_Hal_Compiler_Iar.c Os_Hal_Context_v7m.c Os_Hal_ContextAsm.asm Os_Hal_Core.c Os_Hal_Entry.c Os_Hook.c Os_Interrupt.c Os_Ioc.c Os_Isr.c Os_Job.c Os_Lock.c Os_MemoryProtection.c Os_Peripheral.c Os_PriorityQueue.c Os_Resource.c Os_Scheduler.c Os_ScheduleTable.c Os_ServiceFunction.c Os_Spinlock.c Os_Stack.c Os_Task.c Os_Thread.c Os_Timer.c Os_TimingProtection.c Os_Trace.c Os_Trap.c Os_XSignal.c
  group Bsw/PduR
    Src/Bsw/PduR/: PduR.c PduR_Bm.c PduR_Fm.c PduR_Lock.c PduR_McQ.c PduR_RmIf.c PduR_RmTp.c PduR_RmTp_TxInst.c PduR_Sm.c
  group Bsw/RamTst
    Src/Bsw/RamTst/: RamTst.c
  group Bsw/Vstdlib
    Src/Bsw/VStdLib/: vstdlib.c
  group Bsw/WdgIf
    Src/Bsw/WdgIf/: WdgIf.c
  group Bsw/WdgM
    Src/Bsw/WdgM/: WdgM.c WdgM_Checkpoint.c
  group Devices
    Src/Devices/: callbacks.h devassert.h device_registers.h s32_core_cm4.h S32K148.h S32K148_features.h S32K148Asr.icf startup.c startup.h startup_S32K148.s status.h system_S32K148.c system_S32K148.h
  group Isr
    Src/Isr/: interrupt_manager.c interrupt_manager.h
  group Mcal/Adc
    Src/Mcal/Adc_TS_T40D2M10I1R0/src/: Adc.c Adc_Adc12bsarv2.c Adc_Adc12bsarv2_Irq.c Adc_Ipw.c Adc_Pdb.c Adc_Pdb_Irq.c
  group Mcal/Dio
    Src/Mcal/Dio_TS_T40D2M10I1R0/src/: Dio.c Dio_Gpio.c
  group Mcal/Eep
    Src/Mcal/Eep_TS_T40D2M10I1R0/src/: Eep.c Eep_Ac.c Eep_Irq.c
  group Mcal/Fls
    Src/Mcal/Fls_TS_T40D2M10I1R0/src/: Fls.c Fls_Ac.c Fls_Flash.c Fls_Flash_Const.c Fls_IPW.c Fls_Qspi.c Fls_Qspi_Irq.c
  group Mcal/GenCode
    Src/Mcal/GenCode/Src/: Adc_Cfg.c Adc_PBcfg.c CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Eep_Cfg.c Eep_PBcfg.c Fls_Cfg.c Fls_PBcfg.c Gpt_PBcfg.c Icu_Cfg.c Icu_DmaNotification.c Icu_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c Pwm_PBcfg.c Spi_Cfg.c Spi_PBcfg.c Wdg_Cfg.c Wdg_CfgExt.c Wdg_Lcfg.c Wdg_PBcfg.c
  group Mcal/Gpt
    Src/Mcal/Gpt_TS_T40D2M10I1R0/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group Mcal/Icu
    Src/Mcal/Icu_TS_T40D2M10I1R0/src/: Icu.c Icu_Ftm.c Icu_Ipw.c Icu_LPit.c Icu_Lptmr.c Icu_Port_Ci.c Icu_Port_Ci_Irq.c
  group Mcal/Mcl
    Src/Mcal/Mcl_TS_T40D2M10I1R0/src/: CDD_Mcl.c Ftm_Common.c LPit_Common.c Lptmr_Common.c Mcl_Dma.c Mcl_Dma_Irq.c Mcl_DmaMux.c Mcl_IPW.c Mcl_Lmem.c Mcl_TrgMux.c
  group Mcal/Mcu
    Src/Mcal/Mcu_TS_T40D2M10I1R0/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group Mcal/Port
    Src/Mcal/Port_TS_T40D2M10I1R0/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group Mcal/Pwm
    Src/Mcal/Pwm_TS_T40D2M10I1R0/src/: Pwm.c Pwm_Ftm.c Pwm_Ipw.c
  group Mcal/Spi
    Src/Mcal/Spi_TS_T40D2M10I1R0/src/: Spi.c Spi_LPspi.c Spi_LPspi_Irq.c
  group Mcal/Wdg
    Src/Mcal/Wdg_TS_T40D2M10I1R0/src/: Wdg.c Wdg_Channel.c Wdg_Wdog.c Wdg_Wdog_Isr.c

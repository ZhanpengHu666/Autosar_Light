<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\CBD1800257_D01_S32K1xx\Applications\S32K144_Start_new_IAR\ASR_S32K144_Start.ewp</path>
    </project>
    <batchBuild />
</workspace>
